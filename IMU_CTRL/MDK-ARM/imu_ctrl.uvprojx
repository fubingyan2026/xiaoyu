# Keil uVision project imu_ctrl.uvprojx, settings and files
target imu_ctrl (6090000::V6.9::.\ARMCLANG)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: imu_ctrl +hex
  AfterMake: D:\KEIL5\ARM\ARMCC\bin\keil-build-viewer.exe
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=4 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../applications;../hal_drivers;../modules/CmBacktrace/cm_backtrace;../modules/SEGGER_RTT/RTT;../modules/SEGGER_RTT/RTT/config;../modules/easyflash/inc;../modules;../modules/lwmem/include;../modules/lwshell/inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;..\portable\GCC\ARM_CM4F
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10
  memory RVCT10: RAM 0x20000010 size 0x7ff0
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c dma.c fdcan.c i2c.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group hal_drivers
    ../hal_drivers/: hal_fdcan.c hal_gpio.c hal_tim_pwm.c hal_uart.c stm32_hal_fdcan.c stm32_hal_gpio.c stm32_hal_tim_pwm.c stm32_hal_uart.c
  group applications
    ../applications/: app.c bsp_delay.c CAN_Server.c ins_task.c key_function.c perf_counter.c PS4_Controller.c usart_receive.c warning_task.c ws2812_tim.c gimbal_task.c
  group modules
    ../modules/algorithm/: filter.c maths.c user_lib.c utils_math.c
    ../modules/can_comm/: can_comm.c can_comm_port.c can_nm.c
    ../modules/controller/: gimbal_pid.c pid.c
    ../modules/crc/: crc.c
    ../modules/daemon/: daemon.c
    ../modules/debug/: debug.c
    ../modules/keybase/: key_base.c
    ../modules/kfifo/: kfifo.c
    ../modules/ledshow/: led.c
    ../modules/lwmem/src/lwmem/: lwmem.c
    ../modules/lwshell/src/: lwshell.c
    ../modules/memory_pool/: memory_pool.c
    ../modules/message_center/: message_center.c
    ../modules/protocol/: b_protocol_core.c
    ../modules/toolkit/: tk_event.c tk_queue.c tk_timer.c
    ../modules/utils/: printf.c
  group modules/CmBacktrace
    ../modules/CmBacktrace/cm_backtrace/: cm_backtrace.c
    ../modules/CmBacktrace/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group modules/SEGGER_RTT
    ../modules/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group modules/easyflash
    ../modules/easyflash/src/: easyflash.c ef_env.c ef_utils.c
    ../modules/easyflash/port/: ef_port.c
    ../modules/easyflash/inc/: ef_cfg.h ef_def.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group portable
    ../portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.1.1
