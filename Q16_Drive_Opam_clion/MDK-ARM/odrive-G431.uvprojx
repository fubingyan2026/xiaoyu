# Keil uVision project odrive-G431.uvprojx, settings and files
target odrive-G431 (6090000::V6.9::.\ARMCLANG)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: odrive-foc +hex
  AfterMake: D:\KEIL5\ARM\ARMCC\bin\keil-build-viewer.exe
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=4 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx,ARM_MATH_CM4,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../applications;..\hal_drivers;..\modules\CmBacktrace\cm_backtrace;..\modules\SEGGER_RTT\RTT;..\modules\SEGGER_RTT\RTT\config;..\modules\easyflash\inc;..\modules;..\modules\lwmem\include;..\modules\lwshell\inc;..\Q16_FOC;..\applications
  memory RVCT4: ROM 0x8000000 size 0x1e000
  memory RVCT9: RAM 0x20000020 size 0x7fe0
  memory RVCT10: RAM 0x20000000 size 0x20
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c opamp.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group hal_drivers
    ../hal_drivers/: hal_gpio.c hal_tim_pwm.c hal_fdcan.c hal_uart.c stm32_hal_gpio.c stm32_hal_tim_pwm.c stm32_hal_fdcan.c stm32_hal_uart.c
  group applications
    ../applications/: app.c bsp_delay.c CAN_Server.c hall_adjustment.c key_function.c perf_counter.c usart_receive.c warning_task.c WS2812_SPI.c encoder_alignment.c encoder_alignment.h flash_task.c
  group modules
    ../modules/algorithm/: utils_math.c user_lib.c maths.c joint_pos.c filter.c
    ../modules/controller/: pid.c gimbal_pid.c
    ../modules/crc/: crc.c
    ../modules/daemon/: daemon.c
    ../modules/keybase/: key_base.c
    ../modules/ledshow/: led.c
    ../modules/memory_pool/: memory_pool.c
    ../modules/message_center/: message_center.c
    ../modules/debug/: debug.c
    ../modules/kfifo/: kfifo.c kqueue.c
    ../modules/protocol/: b_protocol_core.c
    ../modules/toolkit/: tk_event.c tk_queue.c tk_timer.c
    ../modules/encoder/: line_hall_pll.c MT6816.c
    ../modules/lwmem/src/lwmem/: lwmem.c
    ../modules/lwshell/src/: lwshell.c
    ../modules/fsm/: fsm.c
  group modules/easyflash
    ../modules/easyflash/src/: easyflash.c ef_env.c ef_utils.c
    ../modules/easyflash/port/: ef_port.c
    ../modules/easyflash/inc/: ef_cfg.h ef_def.h
  group modules/CmBacktrace
    ../modules/CmBacktrace/cm_backtrace/: cm_backtrace.c
    ../modules/CmBacktrace/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group modules/SEGGER_RTT
    ../modules/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group modules/can_comm
    ../modules/can_comm/: can_nm.c can_comm.c can_comm_port.c
  group Q16_FOC
    ../Q16_FOC/: foc_ctrl_q16.c foc_fsm.c foc_svpwm_q16.c q16_16_math.c foc_config_q16.h q16_16_math.h foc_port.c
software components: CMSIS:CORE 5.1.1
